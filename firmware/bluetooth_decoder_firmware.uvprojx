# Keil uVision project bluetooth_decoder_firmware.uvprojx, settings and files
target bluetooth_decoder (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: bluetooth_decoder_firmware +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F030x8 USE_FULL_LL_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ./user/: main.c io.c io.h queue.c queue.h usart_io_base.c usart_io_base.h usart_io.c usart_io.h usart_interrupt.c usart_interrupt.h
software components: CMSIS:CORE 5.3.0, Device:STM32Cube LL:ADC 1.7.0, Device:STM32Cube LL:COMMON 1.7.0, Device:STM32Cube LL:COMP 1.7.0, Device:STM32Cube LL:CRC 1.7.0, Device:STM32Cube LL:CRS 1.7.0, Device:STM32Cube LL:DAC 1.7.0, Device:STM32Cube LL:DMA 1.7.0, Device:STM32Cube LL:EXTI 1.7.0, Device:STM32Cube LL:GPIO 1.7.0, Device:STM32Cube LL:I2C 1.7.0, Device:STM32Cube LL:PWR 1.7.0, Device:STM32Cube LL:RCC 1.7.0, Device:STM32Cube LL:RTC 1.7.0, Device:STM32Cube LL:SPI 1.7.0, Device:STM32Cube LL:TIM 1.7.0, Device:STM32Cube LL:USART 1.7.0, Device:STM32Cube LL:UTILS 1.7.0, Device:Startup 1.0.0
